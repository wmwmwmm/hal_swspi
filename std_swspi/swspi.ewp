# IAR project swspi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: C:\Users\G\Desktop\code repo\f3rc_spi\std_swspi\lib\inc; C:\Users\G\Desktop\code repo\f3rc_spi\std_swspi\lib\CMSIS\CM3\CoreSupport; C:\Users\G\Desktop\code repo\f3rc_spi\std_swspi\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: swspi.srec
  ILINK.IlinkOutputFile: swspi.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group CMSIS
    lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Std
    lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
